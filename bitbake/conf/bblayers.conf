## bitbake/conf/bblayers.conf
```bitbake
BBPATH := "${TOPDIR}"
BBFILES ?= ""
BBLAYERS = "${TOPDIR}/meta"
CACHE = "${TOPDIR}/cache"
```
